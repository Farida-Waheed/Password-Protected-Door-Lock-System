# Keil uVision project HomeSystem.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: HomeSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Buzzer.c Buzzer.h keypad.c keypad.h lcd.c lcd.h delay.c delay.h IR_Sensor.c IR_Sensor.h leds.c leds.h servo.c uart.c servo.h uart.h button.c button.h
